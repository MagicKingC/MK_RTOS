# Keil uVision project MKRTOS.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: MKRTOS
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c include: ..\kernel\data_type;..\kernel\include;..\kernel\libcpu\m3;..\kernel\source;..\kernel\list
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group App
    ../app/: main.c
  group kernel/data_type
    ../kernel/data_type/: data_type.c
  group kernel/include
    ../kernel/include/: mkrtos.h system.h switch.h mkrtos_inc.h mkrtos_config.h priority.h
  group kernel/source
    ../kernel/source/: system.c switch.c idle.c delay.c time_stamp.c priority.c
  group kernel/libcpu/m3
    ../kernel/libcpu/m3/: cpu.s systick.c cpu_o.asm
  group kernel/list
    ../kernel/list/: list.c list.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.2.2
