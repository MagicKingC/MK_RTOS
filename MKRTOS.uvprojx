# Keil uVision project MKRTOS.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: MKRTOS
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\kernel\data_type;.\kernel\include;.\kernel\libcpu\m3;.\kernel\source;.\kernel\list
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group App
    ./app/: main.c
  group kernel/data_type
    ./kernel/data_type/: data_type.h data_type.c
  group kernel/include
    ./kernel/include/: mkrtos.h system.h
  group kernel/source
    ./kernel/source/: system.c
  group kernel/libcpu/m3
    ./kernel/libcpu/m3/: cpu.s
  group kernel/list
    ./kernel/list/: list.c list.h
software components: CMSIS:CORE 5.3.0, Device:Startup 1.2.0
